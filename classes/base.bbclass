addtask do_build
